# IAR project binex_1.0.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; CMSIS\; fsm\; utils\; drivers\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: binex_1.0.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: core_cm0.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f030x6.s stm32f030x6.h stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group drivers
    drivers/: SysClock.c SysClock.h uart.c uart.h
  group fsm
    fsm/: binex.c binex.h
  group utils
    utils/: crc16.c crc16.h fifo.c fifo.h
